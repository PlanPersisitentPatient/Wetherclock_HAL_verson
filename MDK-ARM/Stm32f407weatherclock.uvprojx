# Keil uVision project Stm32f407weatherclock.uvprojx, settings and files
target Stm32f407weatherclock (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Stm32f407weatherclock +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../code_func;../code_driver;../code_driver/font;../code_driver/image;../code_func/page
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group code_func
    ../code_func/: headfile.h board.c wifi.c app.h weather.c mloop.c
  group code_driver
    ../code_driver/: cpu_delay.c st7789.c st7789.h cpu_delay.h aht20.c aht20.h esp_at.c esp_at.h rtc_driver.c rtc_driver.h
  group code_driver/font
    ../code_driver/font/: font.c font.h font_size16.c font_size20.c font24_maple_semibold.c font76_maple_extrabold.c
  group code_driver/image
    ../code_driver/image/: image.h img_first_welcome.c img_error.c img_wifi.c icon_wifi.c icon_wenduji.c icon_duoyun.c icon_leizhenyu.c icon_qing.c icon_yintian.c icon_yueliang.c icon_zhongxue.c icon_zhongyu.c icon_na.c
  group code_func_page
    ../code_func/page/: first_welcome_page.c page.h error_page.c wifi_page.c main_page.c
software components: CMSIS:CORE 4.3.0
